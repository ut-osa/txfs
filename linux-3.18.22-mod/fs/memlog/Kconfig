## linux-3.18.22-mod/fs/memlog/Kconfig
```kconfig
config MEMLOG
	bool "In-memory rollback log for file system transactions."
	default y
```
